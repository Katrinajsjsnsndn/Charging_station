# Keil uVision project APM32E_Master_Node.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: APM32E103RE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: APM32E_Master_Node
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Boards;.\Boards\Board_APM32E103_MINI\inc;.\Library\inc;.\Start;.\User;.\FreeRTOS\include;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS;.\FreeRTOS\portable\RVDS\ARM_CM3;.\APP\tft;.\APP\rs485;.\APP;.\lvgl;.\lvgl\examples\porting;.\lvgl\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./User/: apm32e10x_int.c main.c system_apm32e10x.c my_init.c
  group DRIVER
    ./Library/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_usb_device.c apm32e10x_wwdt.c
  group BOARD
    ./Boards/: Board.c
    ./Boards/Board_APM32E103_MINI/src/: bsp_delay.c bsp_key.c bsp_sdio.c
  group Start
    ./Start/: startup_apm32e10x_hd.s
  group Freertos
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group APP
    ./APP/tft/: LCD.c test code.c
    ./APP/rs485/: rs485.c
    ./APP/: charge_control.c charging_station_ui.c
  group lvgl
    ./lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ./lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./lvgl/src/extra/layouts/flex/: lv_flex.c
    ./lvgl/src/extra/layouts/grid/: lv_grid.c
    ./lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./lvgl/src/extra/themes/default/: lv_theme_default.c
    ./lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./lvgl/src/extra/widgets/chart/: lv_chart.c
    ./lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./lvgl/src/extra/widgets/led/: lv_led.c
    ./lvgl/src/extra/widgets/list/: lv_list.c
    ./lvgl/src/extra/widgets/menu/: lv_menu.c
    ./lvgl/src/extra/widgets/meter/: lv_meter.c
    ./lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./lvgl/src/extra/widgets/span/: lv_span.c
    ./lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./lvgl/src/extra/widgets/win/: lv_win.c
    ./lvgl/src/extra/: lv_extra.c
  group lvgl_port
    ./lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
